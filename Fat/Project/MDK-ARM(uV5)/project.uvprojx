# Keil uVision project project.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,ARM_MATH_CM4,USE_USB_OTG_FS,
  c misc: --diag_suppress=870
  c include: ..\..\User;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\FreeRTOS-Plus-TCP\include;..\..\FreeRTOS-Plus-TCP\portable\Compiler\ARMCC;..\..\FreeRTOS-Plus-TCP\portable\NetworkInterface\include;..\..\User\bsp_stm32f4xx;..\..\User\bsp_stm32f4xx\inc;..\..\User\task\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\mavlink\v1.0;..\..\Libraries\mavlink\v1.0\ground_station;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc;..\..\User\usb_vcp\inc;..\..\Libraries\STemWin\Config;..\..\Libraries\STemWin\inc;..\..\User\gui\inc;..\..\FreeRTOS-Plus-FAT\include;..\..\FreeRTOS-Plus-FAT\portable\common;..\..\FreeRTOS-Plus-CLI;..\..\User\cli;..\..\Libraries\STemWin\PNG;..\..\User\k_modules;..\..\Libraries\MQTT\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/bsp_stm32f4xx/inc/: config.h
    ../../User/: FreeRTOSConfig.h FreeRTOSIPConfig.h main.c filelist.h
    ../../FreeRTOS-Plus-FAT/include/: FreeRTOSFATConfig.h
    ../../User/bsp_stm32f4xx/: stm32f4xx_it.c
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group Application/User/Gui
    ../../User/gui/src/: pictureplay_win.c menu_src.c vedioplay_win.c GUI_SPY.c
    ../../Libraries/STemWin/Sample/Tutorial/MTOUCH_PictureViewer/: MTOUCH_PictureViewer.c
  group k_modules
    ../../User/k_modules/: k_bsp.c k_manu.c k_module.c k_rtc.c k_startup.c k_storage.c
  group TASK
    ../../User/task/src/: task_init.c task_gui.c task_touch.c task_fat.c
    ../../User/network/mqtt/: reconnect_subscriber.c simple_publish.c simple_subscriber.c
  group BSP
    ../../User/bsp_stm32f4xx/src/: bsp_file.c bsp_cli.c sd_test.c bsp_gpio.c bsp_sdio.c bsp_uart.c bsp_eth.c bsp_i2c.c bsp_random.c bsp_lcd.c bsp_lcd_NT35510.c bsp_touch.c bsp_lcd_SSD1963.c bsp_touch_GT9147.c bsp_touch_FT5206.c bsp_sram.c
    ../../User/: fattest.c
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_iwdg.c stm32f4xx_tim.c stm32f4xx_wwdg.c stm32f4xx_crc.c stm32f4xx_spi.c stm32f4xx_fsmc.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dac.c stm32f4xx_flash.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rng.c
    ../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group CMSIS
    ../../User/bsp_stm32f4xx/: system_stm32f4xx.c
  group FreeRTOS/Source
    ../../FreeRTOS/: timers.c croutine.c list.c queue.c tasks.c event_groups.c
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS-Plus-TCP
    ../../FreeRTOS-Plus-TCP/: FreeRTOS_ARP.c FreeRTOS_DHCP.c FreeRTOS_DNS.c FreeRTOS_IP.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_WIN.c FreeRTOS_UDP_IP.c
  group FreeRTOS-Plus-TCP/portable
    ../../User/network/: NetInfoConfig.c
    ../../FreeRTOS-Plus-TCP/portable/BufferManagement/: BufferAllocation_2.c
    ../../FreeRTOS-Plus-TCP/portable/NetworkInterface/STM32F407/: NetworkInterface.c
    ../../FreeRTOS-Plus-TCP/portable/NetworkInterface/Common/: phyHandling.c
  group MQTT
    ../../Libraries/MQTT/src/: mqtt.c mqtt_pal.c
  group USB_OTG
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_DEVICE
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB_VCP
    ../../User/usb_vcp/inc/: usb_conf.h
    ../../User/usb_vcp/src/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group STemWin/Config
    ../../Libraries/STemWin/Config/: GUI_X_Touch_Analog.c GUIConf.c LCDConf.c GUIDRV.c
  group STemWin/Lib
    ../../Libraries/STemWin/Lib/: STemWin540_CM4_OS_Keil_ARGB.lib
  group STemWin/OS
    ../../Libraries/STemWin/OS/: GUI_X_FreeRTOS.c
  group STemWin/GUI
    ../../User/gui/src/: GUIPicture_Port.c picture_player_res.c picture.c file.c alphatest.c
  group STemWin/Doc
    ../../Libraries/STemWin/: Graphic_readme.txt Text_readme.txt Touch_readme.txt Basics.txt
  group STemWin/PNG
    ../../Libraries/STemWin/PNG/: PNG.lib
  group FreeRTOS-Plus-FAT
    ../../FreeRTOS-Plus-FAT/: ff_crc.c ff_dev_support.c ff_dir.c ff_error.c ff_fat.c ff_file.c ff_format.c ff_ioman.c ff_locking.c ff_memory.c ff_stdio.c ff_string.c ff_sys.c ff_time.c
  group FreeRTOS-Plus-FAT/portable
    ../../FreeRTOS-Plus-FAT/portable/STM32F4xx/: ff_sddisk.c
  group FreeRTOP-CLI
    ../../FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
    ../../User/cli/: File-related-CLI-commands.c UARTCommandConsole.c
target CpuRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output
  AfterMake: CopyHex_CpuRAM.bat
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,ARM_MATH_CM4,__CC_ARM,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\bsp;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ExtSRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: output +hex
  AfterMake: CopyHex_ExtSRAM.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.1.1
