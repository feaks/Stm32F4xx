# Keil uVision project project.uvprojx, settings and files
target project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\..\User;..\..\User\bsp;..\..\ucosiii\uC-Conf;..\..\ucosiii\uC-CPU\ARM-Cortex-M4\RealView;..\..\ucosiii\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\ucosiii\uC-LIB;..\..\ucosiii\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\ucosiii\uCOS-III\Source;..\..\ucosiii\uC-CPU;..\..\ucosiii\uC-Bsp
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c stm32f4xx_it.c
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c
  group uC/Conf
    ../../ucosiii/uC-Conf/: cpu_cfg.h includes.h lib_cfg.h os_cfg.h os_cfg_app.h os_app_hooks.c
  group uC/Ports
    ../../ucosiii/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_a.asm os_cpu_c.c
  group uC/CPU
    ../../ucosiii/uC-CPU/: cpu_core.c
    ../../ucosiii/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c
  group uC/Lib
    ../../ucosiii/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../ucosiii/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/Core
    ../../ucosiii/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c os.h os_type.h
  group uC/Bsp
    ../../ucosiii/uC-Bsp/: bsp.c
software components: CMSIS:DSP 1.4.6
